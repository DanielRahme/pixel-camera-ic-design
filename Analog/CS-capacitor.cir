[aimspice]
[description]
43
CS-capacitor

vds 1 0 dc 1.8

CS 1 0 3p
[dc]
1
vds
0
1.8
0.1
[ana]
1 1
0
1 1
1 1 -2 6
1
i(vds)
[end]
